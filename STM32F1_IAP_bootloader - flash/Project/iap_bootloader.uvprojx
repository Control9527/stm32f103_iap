# Keil uVision project iap_bootloader.uvprojx, settings and files
target bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iap_bootloader +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Objects\iap.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\BSP;..\CMSIS\startup\arm;..\CMSIS;..\FWlib\inc;..\USER;..\Utilities;..\APP
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c stm32f10x_it.c header.h
  group BSP
    ../BSP/: Bsp_flash.c Bsp_gpio.c Bsp_timer.c Bsp_uart.c
  group CMSIS
    ../CMSIS/: system_stm32f10x.c
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group LIB
    ../FWlib/src/: misc.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c
